## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
        bool "LDD"
        help
          Includes the Driver Development rules and builds.
```
